# IAR project cc1101-ps2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: HAL_HW_F149
  ICC430.newCCIncludePaths: hal\include; hal\target; lib\include; lib\cc1101\include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: files.txt main.c main.h
  group HAL
    hal/include/: hal.h
  group HAL/Common/GPIO HAL
    hal/include/: hal_gpio.h
  group HAL/Common/Hardware definitions
    hal/include/: hal_hwdef.h
  group HAL/Common/SPI HAL
    hal/src/: hal_spi.c
    hal/include/: hal_spi.h
  group HAL/Common/System Clock HAL
    hal/src/: hal_clk.c
    hal/include/: hal_clk.h
  group HAL/Common/Timer HAL
    hal/src/: hal_timer.c
    hal/include/: hal_timer.h
  group HAL/Target-specific/MSP430F149
    hal/target/f149/: hal_hwdef_f149.h
  group Libraries/CC1101/Include
    lib/cc1101/include/: CC1100-CC2500.h cc1101.h TI_CC_CC1100-CC2500.h TI_CC_hardware_board_EXP5438.h TI_CC_msp430.h TI_CC_spi.h
  group Libraries/CC1101/Source
    lib/cc1101/src/: CC1100-CC2500.c main.c TI_CC_spi.c
  group Libraries/Delay
    lib/src/: delay.c
    lib/include/: delay.h
  group Libraries/PS2 controller
    lib/src/: ps2.c
    lib/include/: ps2.h
